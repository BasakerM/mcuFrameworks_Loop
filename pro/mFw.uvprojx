# Keil uVision project mFw.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mFw
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,USE_STM324xG_EVAL
  c include: ..\ST;..\ST\stlib\inc;..\mCore;..\mDriver\uart
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group ST
    ../ST/: stm32f4xx_it.c system_stm32f4xx.c startup_stm32f40_41xxx.s
    ../ST/stlib/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_usart.c
  group mCore
    ../mCore/: m_thread_switch.S main.c mConfig.c
  group mDriver
    ../mDriver/uart/: mUart1Driver.c
  group mTask
    ../mTask/: mTask_console.c mTask_msgTestP.c mTask_msgTestS.c mTask_template.c
